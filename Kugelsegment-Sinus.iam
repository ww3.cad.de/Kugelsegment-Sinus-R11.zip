# Autodesk Inventor assembly: Kugelsegment-Sinus
## iProperties
Created: 2006-08
Part Number: Kugelsegment-Sinus
Document SubType Name: Assembly
Designer: W. Holzwarth
Author: W. Holzwarth
